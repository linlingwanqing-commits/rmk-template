## nrf52840_ble/west.yml
```yaml
manifest:
  projects:
    - name: sdk-nrfxlib
      url: https://github.com/nrfconnect/sdk-nrfxlib
      revision: main
  self:
    path: app
```
